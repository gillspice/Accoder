# Keil uVision project USBFS_MIDI_PSoC3_5LP01_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: USBFS_MIDI_PSoC3_5LP01_PSoC3lib (library)
  c flags: Optimize=2
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: CODE RU RC(10) IX CL(XDATA(X:0x0000-X:0x1FFF)) CL(CODE(C:0x0000-C:0xFFFF)) CL(CONST(C:0x0000-C:0xFFFF))
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h SW2.c SW2.h SW2_aliases.h SleepTimer.c SleepTimer.h SW1.c SW1.h SW1_aliases.h MIDI_PWR.c MIDI_PWR.h MIDI_PWR_aliases.h LED_OutB.c LED_OutB.h LED_OutB_aliases.h LED_InB.c LED_InB.h LED_InB_aliases.h LED_OutA.c LED_OutA.h LED_OutA_aliases.h LED_InA.c LED_InA.h LED_InA_aliases.h MIDI1_UART.c MIDI1_UART.h MIDI1_UART_PM.c MIDI1_UART_INT.c MIDI1_UART_BOOT.c MIDI2_UART.c MIDI2_UART.h MIDI2_UART_PM.c MIDI2_UART_INT.c MIDI2_UART_BOOT.c Clock_1.c Clock_1.h USB.c USB.h USB_audio.c USB_audio.h USB_boot.c USB_cdc.c USB_cdc.h USB_cls.c USB_descr.c USB_drv.c USB_episr.c USB_hid.c USB_hid.h USB_pm.c USB_std.c USB_vnd.c USB_cdc.inf USB_midi.c USB_midi.h USB_pvt.h USB_cydmac.h USB_msc.c USB_msc.h Sleep_isr.c Sleep_isr.h USB_Dm.c USB_Dm.h USB_Dm_aliases.h USB_Dp.c USB_Dp.h USB_Dp_aliases.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h cycodeshareimport.ld cycodeshareexport.ld cycodeshareimport.scat
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: USBFS_MIDI_PSoC3_5LP01_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: as above
